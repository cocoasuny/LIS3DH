# Keil uVision project Redhare.uvproj, settings and files
target RedHare-STM32 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32L151VC STMicroelectronics
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: RedHare-STM32-App +hex
  AfterMake: fromelf --bin -o ./output/Redhare_MA_App_V4.1_V2.0.0.bin ./Obj/RedHare-STM32-App.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32L1XX_HD ARM_MATH_CM3
  c include: ..\Source\Libraries\CMSIS;..\Source\Libraries\STM32L1xx_StdPeriph_Driver\inc;..\Source\Application;..\Source\Drivers;..\Source\Libraries\STM32_CPAL_Driver\inc;..\Source\Libraries\STM32_CPAL_Driver\devices;..\Source\Arithmetic;..\Source\Libraries\CMSIS\DSP_Lib;..\Source\Libraries\CMSIS\DSP_Lib\Source\FilteringFunctions;..\Source\TS\Source;..\Source\TS\Interface;..\Source\Libraries\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x1cd00
  memory RVCT9: RAM 0x20000000 size 0x8000
  group startup
    ../Source/Libraries/CMSIS/starup/: startup_stm32l1xx_hd.s
  group Application
    ../Source/Application/: main.c stm32l1xx_it.c Monitoer_Template.c ParameterLimit.c SyncData.c BatteryMonitor.c Charge.c CRC.c flash_if.c FWUpdate.c Process_Acc_Data.c bootUpdate.c Call.c DeviceCtl.c AlarmCtrl.c step.c DataEEPROM.c DataMemoryManage.c StoreManage.c
    ../Source/Drivers/: font.c
    ../Source/Libraries/CMSIS/: system_stm32l1xx.c
  group Drivers
    ../Source/Drivers/: Usart.c Timer.c Key.c calendar.c BasicTimer.c AFE44x0.c SPI.c Display.c OLED_MXS8475.c MotorCtl.c SecondTick.c PowerManage.c bma2x2.c bma250e.c MX25L1606E.c led.c lis3dh_driver.c bsp_accelero.c
  group Library
    ../Source/Libraries/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_aes.c stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_gpio.c stm32l1xx_iwdg.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_adc.c
    ../Source/Libraries/CMSIS/DSP_Lib/Source/TransformFunctions/: arm_bitreversal.c arm_cfft_radix4_init_q31.c arm_cfft_radix4_q31.c arm_cfft_radix2_init_q31.c arm_cfft_radix2_q31.c
    ../Source/Libraries/CMSIS/DSP_Lib/Source/CommonTables/: arm_common_tables.c
    ../Source/Libraries/CMSIS/DSP_Lib/Source/StatisticsFunctions/: arm_mean_q31.c
    ../Source/Libraries/CMSIS/DSP_Lib/Source/BasicMathFunctions/: arm_dot_prod_q31.c
    ../Source/Libraries/CMSIS/DSP_Lib/Source/ComplexMathFunctions/: arm_cmplx_mag_q31.c
    ../Source/Libraries/CMSIS/DSP_Lib/Source/FastMathFunctions/: arm_sqrt_q31.c
    ../Source/Libraries/CMSIS/DSP_Lib/Source/FilteringFunctions/: arm_biquad_cascade_df1_init_q15.c arm_biquad_cascade_df1_q15.c arm_fir_init_q15.c arm_fir_q15.c arm_biquad_cascade_df1_init_q31.c arm_biquad_cascade_df1_q31.c
    ../Source/Libraries/CMSIS/DSP_Lib/Source/SupportFunctions/: arm_copy_q15.c
  group TS
    ../Source/TS/Source/: TS_Kernel.c FunctionLib.c list.c
  group Arithmetic
    ../Source/Arithmetic/: cc_alg_app_interface.c cc_afe_translate_layer.c cc_app_afe_drv_interface.c cc_gsensor_translate_layer.c cc_app_gsensor_drv_interface.c gSensor_data_process.c cc_alg.lib
